# IAR project GPIO Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: UserCodes\inc; Libraries\CMSIS\Core\CM3; Libraries\STM32_USB-FS-Device_Driver\inc; Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: GPIO Demo.srec
  ILINK.IlinkOutputFile: GPIO Demo.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group EWARMv5
    Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group User
    UserCodes/src/: hw_config.c main.c
